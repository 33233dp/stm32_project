# Keil uVision project BH-F103.uvprojx, settings and files
target USART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\usart;..\..\User\OLED;..\..\User\SG90;..\..\User\KEY;..\..\User\delay;..\..\User;..\..\Project;..\RVMDK（uv4）;..\..\User\Motor;..\..\User\base_timer;..\..\User\U_timer;..\..\User\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart.c bsp_usart.h
    ../../User/OLED/: OLED.h OLED_Font.h OLED.c
    ../../User/LED/: LED.c LED.h
    ../../User/SG90/: bsp_AdvanceTim_PWM_SG90.h bsp_AdvanceTim_PWM_SG90.c
    ../../User/KEY/: Key.h Key.c
    ../../User/delay/: Delay.h Delay.c
    ./: IF_Tracing.h IF_Tracing.c
    ../../User/Motor/: Motor.h Motor.c
    ../../User/U_timer/: bsp_GeneralTim.c bsp_GeneralTim.h
    ../../User/PWM/: PWM.c PWM.h
